FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Boot-a-wandboard-revb1-board.patch"
